# Keil uVision project Switches.uvprojx, settings and files
target STM32F407 Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F407xx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,HSE_VALUE=8000000,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./: LED.c SWT.c retarget.c serial.c Main.c Breadboard.c Voltage.c lcd_buffer.c lcd_driver.c Buttons.c Resistance.c Light.c Current.c Transistor.c Capacitance.c Timer.c Frequency.c Logic.c
  group Documentation
    ./: Abstract.txt
software components: CMSIS:CORE 5.0.0, Device:Startup 2.5.0
